# Keil uVision project Lt1605_mlcode.uvproj, settings and files
target LT7911_mlcode (MCS-51)
  device: AT89C5130 Atmel
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x3FFF) CLOCK(32000000) MODP2
  output: LT7911D_DP2DSI_800x1280_038225090201 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User
  group code
    ./: STARTUP.A51
    ../User/: edid.c globalV.c main.c register.c Lt7911.c mipi.c lt1605_dcs.c V26_2024091301.LIB
